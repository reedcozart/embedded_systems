# Keil uVision project ProfileFFT.uvproj, settings and files
target ProfileFFT (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ProfileFFT
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s ProfileFFT.c
